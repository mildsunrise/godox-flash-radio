options:
  parameters:
    generate_options: qt_gui
    id: flash
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 2424.5e6
  states: {}
- name: channel_filter
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 0.4e6
    gain: '1.0'
    samp_rate: samp_rate*decimation
    width: 0.1e6
    win: window.WIN_HAMMING
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '2'
  states: {}
- name: freq_shift
  id: variable
  parameters:
    value: 0.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_shift
    decim: decimation
    samp_rate: samp_rate*decimation
    taps: channel_filter
    type: ccf
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '20000'
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq - freq_shift
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate*decimation
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    rate: '30'
    type: complex
  states: {}

connections:
- [freq_xlating_fir_filter_xxx_0, '0', network_tcp_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
